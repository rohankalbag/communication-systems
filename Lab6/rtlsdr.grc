options:
  parameters:
    generate_options: qt_gui
    id: rtlsdr
    output_language: python
    title: rtlsdr
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 2.048e6
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 1.12e9 + 58*1.25e6
    samp_rate: 2.048e6
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
