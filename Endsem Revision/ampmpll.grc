options:
  parameters:
    author: rohan
    generate_options: qt_gui
    id: ampmpll
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '495000'
    step: '1000'
    stop: '510000'
    value: '500000'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '6.28'
    min_freq: '-6.28'
    w: '50e-3'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rohan/Desktop/EE340/Endsem Revision/PM_AM_Modulated.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {state: bypassed}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14/100
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1]'
    fftaps: '[1, -1]'
    type: ffd
  states: {state: bypassed}
- name: iir_filter_xxx_1
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,1]'
    fftaps: '1'
    type: ffd
  states: {state: bypassed}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 9e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '700'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1500000'
    interp: '44100'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1500000'
    interp: '44100'
    type: fff
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_abs_xx_0, '0', low_pass_filter_0, '0']
- [blocks_abs_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', iir_filter_xxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_abs_xx_0, '0']
- [blocks_file_source_0, '0', hilbert_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', dc_blocker_xx_1, '0']
- [dc_blocker_xx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', blocks_null_sink_0, '0']
- [dc_blocker_xx_1, '0', iir_filter_xxx_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_arg_0, '0']
- [hilbert_fc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [hilbert_fc_0, '0', digital_costas_loop_cc_0, '0']
- [iir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [iir_filter_xxx_1, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', dc_blocker_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0_0, '0']

metadata:
  file_format: 1
